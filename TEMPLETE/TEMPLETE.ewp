# IAR project TEMPLETE.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\LwIP\lwip-1.3.2\src\include\netif; ..\LwIP\lwip-1.3.2\src\include\lwip; ..\LwIP\lwip-1.3.2\src\include\ipv4; ..\LwIP\lwip-1.3.2\src\include\ipv6; ..\BSP\STM32\CMSIS\CM3\CoreSupport; ..\BSP\STM32\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\BSP\STM32\STM32F10x_StdPeriph_Driver\inc; ..\LwIP\arch; ..\APP; ..\BSP; ..\LwIP; ..\LwIP\lwip-1.3.2\src\include; ..\APP\common; ..\APP\enc28j60; ..\APP\LwIP-app
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: TEMPLETE.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: includes.h main.c system_stm32f10x.c
  group APP/ENC28J60
    ../APP/enc28j60/: ENC28J60.C SPI.C
  group APP/LwIP-app
    ../APP/LwIP-app/: cmd.c httpd.c netconfig.c
  group APP/peripheral
    ../APP/common/: led.c SysTick.c usart1.c
  group BSP
    ../APP/Linker/: stm32f10x_flash.icf
  group BSP/CM3
    ../BSP/STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.h
  group BSP/CM3/startup
    ../BSP/STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group BSP/Header
    ../BSP/: bsp.h
  group BSP/Source
    ../BSP/: BSP.c
  group BSP/STM32/inc
    ../BSP/STM32/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group BSP/STM32/src
    ../BSP/STM32/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LwIP/api
    ../LwIP/lwip-1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/arch
    ../LwIP/arch/: cc.h perf.h sys_arch.h
  group LwIP/core
    ../LwIP/lwip-1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LwIP/core-ipv4
    ../LwIP/lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP/netif
    ../LwIP/lwip-1.3.2/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
